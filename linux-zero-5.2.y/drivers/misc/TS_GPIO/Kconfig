## linux-zero-5.2.y/drivers/misc/TS_GPIO/Kconfig
```kconfig
choice

prompt "TS_GPIO Driver Select"

config TS_GPIO_NAS
bool "TS_GPIO_NAS"


config TS_GPIO_CAM
bool "TS_GPIO_Camera"


endchoice
```
